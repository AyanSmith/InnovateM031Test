# Keil uVision project Application.uvproj, settings and files
target MMV (6160000::V6.16::ARMCLANG)
  device: M031LE3AE Nuvoton
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(72000000) CPUTYPE("Cortex-M0")
  output: MMV +hex
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\Library\CMSIS\Include;..\..\Library\Device\Nuvoton\M031\Include;..\..\Library\StdDriver\inc;..\Header
  library: MicroLIB
  memory RVCT4: ROM 0x2000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x4000
  link misc: --map --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../Library/Device/Nuvoton/M031/Source/: system_M031Series.c
    ../../Library/Device/Nuvoton/M031/Source/ARM/: startup_M031Series.s
  group Library
    ../../Library/StdDriver/src/: retarget.c clk.c gpio.c sys.c uart.c i2c.c spi.c adc.c rtc.c timer.c fmc.c
  group User
    ../Source/: Main.c Hardware.c Utilities.c W25Qxx.c NMEAParser.c EMeter.c FMCUser.c Boot.c DS1307.c MComm.c SunPos.c
  group Header
    ../Header/: Hardware.h Utilities.h W25Qxx.h EMeter.h FMCUser.h Boot.h DS1307.h MComm.h SunPos.h
